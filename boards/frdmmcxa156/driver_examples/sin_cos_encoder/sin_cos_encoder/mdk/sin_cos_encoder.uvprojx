# Keil uVision project sin_cos_encoder.uvprojx, settings and files
target sin_cos_encoder (6190000::V6.19::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: tj_yk_encoder +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXA156VLL, MCUXPRESSO_SDK SDK_DEBUGCONSOLE_UART
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../devices/MCXA156/drivers;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MCXA156;../../../../../../devices/MCXA156/utilities/debug_console_lite;../../../../../../CMSIS/Core/Include;../../../../../../devices/MCXA156/utilities/str;..\..\..\..\..\..\CMSIS\DSP\Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: main.c app_adc.c app_lpuart.c app_timer.c app_crc.c app_atan.c app_eqdc.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MCXA156/drivers/: fsl_port.h fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_gpio.h fsl_gpio.c fsl_spc.h fsl_spc.c fsl_inputmux.c fsl_lpadc.c fsl_ctimer.c fsl_crc.c fsl_eqdc.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/MCXA156/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group startup
    ../../../../../../devices/MCXA156/arm/: startup_MCXA156.S
  group utilities
    ../../../../../../devices/MCXA156/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MCXA156/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
