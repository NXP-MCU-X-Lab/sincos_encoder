# IAR project flexio_spi_edma_lpspi_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA156 NXP MCXA156
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXA156VLL; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../..; ../../../../../../../../devices/MCXA156/drivers; ../../../../../../../../components/uart; ../../../../../../../../components/lists; ../../../../../../../../devices/MCXA156; ../../../../../../../../devices/MCXA156/utilities/debug_console_lite; ../../../../../../../../CMSIS/Core/Include; ../../../../../../../../devices/MCXA156/utilities/str
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: flexio_spi_edma_lpspi_transfer_master.out
  ILINK.IlinkIcfFile: MCXA156_flash.icf
  ILINK.IlinkExtraOptions: --cpu=Cortex-M33.no_se
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MCXA156VLL; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  group source
    ../: flexio_spi_edma_lpspi_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../../../devices/MCXA156/drivers/: fsl_edma_soc.h fsl_edma_soc.c fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_port.h fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_lpspi.c fsl_lpspi.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_reset.h fsl_reset.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_spc.h fsl_spc.c
  group component/uart
    ../../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../../devices/MCXA156/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group startup
    ../../../../../../../../devices/MCXA156/iar/: startup_MCXA156.s
  group utilities
    ../../../../../../../../devices/MCXA156/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../../../devices/MCXA156/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
