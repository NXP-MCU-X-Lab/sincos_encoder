# Keil uVision project flexio_mculcd_edma_transfer.uvprojx, settings and files
target flexio_mculcd_edma_transfer debug (6180000::V6.18::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexio_mculcd_edma_transfer.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, BOARD_LCD_S035=1, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../..;../../../../../../../components/st7796s;../../../../../../../devices/MCXA156/drivers;../../../../../../../components/uart;../../../../../../../components/lists;../../../../../../../devices/MCXA156;../../../../../../../devices/MCXA156/utilities/debug_console_lite;../../../../../../../components/video/display/dbi;../../../../../../../CMSIS/Core/Include;../../../../../../../devices/MCXA156/utilities/str
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: flexio_mculcd_edma_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
  group lcdc
    ../../../../../../../components/st7796s/: fsl_st7796s.h fsl_st7796s.c
  group drivers
    ../../../../../../../devices/MCXA156/drivers/: fsl_edma_soc.h fsl_edma_soc.c fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_reset.h fsl_reset.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_spc.h fsl_spc.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../../devices/MCXA156/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group startup
    ../../../../../../../devices/MCXA156/arm/: startup_MCXA156.S
  group utilities
    ../../../../../../../devices/MCXA156/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../../devices/MCXA156/utilities/str/: fsl_str.c fsl_str.h
  group video
    ../../../../../../../components/video/display/dbi/: fsl_dbi.h fsl_dbi.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target flexio_mculcd_edma_transfer release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexio_mculcd_edma_transfer.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOARD_LCD_S035=1, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
