# Keil uVision project i3c_master_read_sensor_p3t1755.uvprojx, settings and files
target i3c_master_read_sensor_p3t1755 debug (6180000::V6.18::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: i3c_master_read_sensor_p3t1755.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../..;../../../../../../devices/MCXA156/drivers;../../../../../../components/p3t1755;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MCXA156;../../../../../../devices/MCXA156/utilities/debug_console_lite;../../../../../../CMSIS/Core/Include;../../../../../../devices/MCXA156/utilities/str
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: i3c_master_read_sensor_p3t1755.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../devices/MCXA156/drivers/: fsl_i3c.h fsl_i3c.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_spc.h fsl_spc.c fsl_inputmux_connections.h
  group component/p3t1755
    ../../../../../../components/p3t1755/: fsl_p3t1755.h fsl_p3t1755.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/MCXA156/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group startup
    ../../../../../../devices/MCXA156/arm/: startup_MCXA156.S
  group utilities
    ../../../../../../devices/MCXA156/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c fsl_assert.h
    ../../../../../../devices/MCXA156/utilities/str/: fsl_str.c fsl_str.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
target i3c_master_read_sensor_p3t1755 release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: i3c_master_read_sensor_p3t1755.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
